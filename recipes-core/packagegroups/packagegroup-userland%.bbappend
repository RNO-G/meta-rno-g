
RDEPENDS:${PN} += "git curl gcc gpsd"
